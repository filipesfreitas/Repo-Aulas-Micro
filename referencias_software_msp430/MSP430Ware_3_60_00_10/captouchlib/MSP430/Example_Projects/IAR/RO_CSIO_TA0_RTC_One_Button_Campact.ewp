# IAR project RO_CSIO_TA0_RTC_One_Button_Campact.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: _MSP430G6021_
  ICC430.newCCIncludePaths: ..\Source\RO_CSIO_TA0_RTC_One_Button_Compact; ..\..\Library
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../../Library/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
    ../Source/RO_CSIO_TA0_RTC_One_Button_Compact/: main.c structure.c structure.h
