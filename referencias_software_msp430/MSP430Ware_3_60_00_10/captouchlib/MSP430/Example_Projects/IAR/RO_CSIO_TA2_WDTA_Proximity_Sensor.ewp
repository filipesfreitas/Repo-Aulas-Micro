# IAR project RO_CSIO_TA2_WDTA_Proximity_Sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430FR5969__
  ICC430.newCCIncludePaths: ..\Source\RO_CSIO_TA2_WDTA_Proximity_Sensor; ..\..\Library
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../../Library/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
    ../Source/RO_CSIO_TA2_WDTA_Proximity_Sensor/: main.c structure.c structure.h
