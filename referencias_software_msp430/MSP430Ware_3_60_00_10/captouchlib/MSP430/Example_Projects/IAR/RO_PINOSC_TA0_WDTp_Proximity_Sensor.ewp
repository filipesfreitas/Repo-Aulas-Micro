# IAR project RO_PINOSC_TA0_WDTp_Proximity_Sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430G2452__
  ICC430.newCCIncludePaths: ..\Source\RO_PINOSC_TA0_WDTp_Proximity_Sensor; ..\..\Library
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../../Library/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
    ../Source/RO_PINOSC_TA0_WDTp_Proximity_Sensor/: main.c structure.c structure.h
